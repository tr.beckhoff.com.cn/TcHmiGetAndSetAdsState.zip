PROGRAM MAIN
VAR
	nCount : INT;
END_VAR

END_PROGRAM
